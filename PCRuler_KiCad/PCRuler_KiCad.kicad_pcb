# Repository JuliCai/PCRuler

## KiCad design PCRuler_KiCad/PCRuler_KiCad.kicad_pcb

Board: 2 copper layers, 314.9 x 23.5 mm, 44 parts (0 on the bottom side), 43 nets.

Parts:
BT1: Battery_Cell; CONN_TSM-102-01-T-SH_SAI
D1: LED; LED_0805_2012Metric
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25: Inolux_IN-PI554FCH; LED_Inolux_IN-PI554FCH_PLCC4_5.0x5.0mm_P3.2mm
J2: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4110
J3: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical_SMD_Pin1Left
R1, R2, R3, R5, R6: 10k; R_0402_1005Metric
R4: 470; R_0402_1005Metric
R7: 2k; R_0402_1005Metric
SW1, SW2, SW3, SW4, SW5: SW_DPST; B3FS-100_OMR
SW6: SW_SPDT; SW_JS102011SCQN
U1: ESP32-C6-MINI-1
U2: MCP73831-2-OT; SOT-23-5
U3: AZ1117CH2-3.3; SOT-223-3_TabPin2

Connections:
+3.3V: D2.3 (VDD), D3.3 (VDD), D4.3 (VDD), D5.3 (VDD), D6.3 (VDD), D7.3 (VDD), D8.3 (VDD), D9.3 (VDD), D10.3 (VDD), D11.3 (VDD), D12.3 (VDD), D13.3 (VDD), D14.3 (VDD), D15.3 (VDD), D16.3 (VDD), D17.3 (VDD), D18.3 (VDD), D19.3 (VDD), D20.3 (VDD), D21.3 (VDD), D22.3 (VDD), D23.3 (VDD), D24.3 (VDD), D25.3 (VDD), R1.1, R3.1, SW2.1, SW2.2, SW3.1, SW3.2, SW5.1, SW5.2, U1.3 (3V3), U3.3 (OUT)
+5V: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R4.1, U2.4 (V_{DD})
+BATT: BT1.1 (+), SW6.2 (B), U2.3 (V_{BAT})
/BOOT: R3.2, SW4.1, SW4.2, U1.23 (IO9)
/BTN_1: R2.1, SW2.3, SW2.4, U1.25 (IO19)
/BTN_2: R5.1, SW3.3, SW3.4, U1.26 (IO20)
/BTN_3: R6.1, SW5.3, SW5.4, U1.27 (IO21)
/LED_DATA: D2.2 (DIN), U1.24 (IO18)
/RESET: R1.2, SW1.1, SW1.2, U1.8 (EN)
/USB_D+: J2.A6 (D+), J2.B6 (D+), U1.18 (IO13)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U1.17 (IO12)
/charger_status: D1.1 (K), U2.1 (STAT)
GND: BT1.2 (-), D2.1 (VSS), D3.1 (VSS), D4.1 (VSS), D5.1 (VSS), D6.1 (VSS), D7.1 (VSS), D8.1 (VSS), D9.1 (VSS), D10.1 (VSS), D11.1 (VSS), D12.1 (VSS), D13.1 (VSS), D14.1 (VSS), D15.1 (VSS), D16.1 (VSS), D17.1 (VSS), D18.1 (VSS), D19.1 (VSS), D20.1 (VSS), D21.1 (VSS), D22.1 (VSS), D23.1 (VSS), D24.1 (VSS), D25.1 (VSS), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R2.2, R5.2, R6.2, R7.2, SW1.3, SW1.4, SW4.3, SW4.4, U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U2.2 (V_{SS}), U3.2 (GND)
unnamed: D1.2 (A), R4.2
unnamed: D2.4 (DO), D3.2 (DIN)
unnamed: D3.4 (DO), D4.2 (DIN)
unnamed: D4.4 (DO), D5.2 (DIN)
unnamed: D5.4 (DO), D6.2 (DIN)
unnamed: D6.4 (DO), D7.2 (DIN)
unnamed: D7.4 (DO), D8.2 (DIN)
unnamed: D8.4 (DO), D9.2 (DIN)
unnamed: D9.4 (DO), D10.2 (DIN)
unnamed: D10.4 (DO), D11.2 (DIN)
unnamed: D11.4 (DO), D12.2 (DIN)
unnamed: D12.4 (DO), D13.2 (DIN)
unnamed: D13.4 (DO), D14.2 (DIN)
unnamed: D14.4 (DO), D15.2 (DIN)
unnamed: D15.4 (DO), D16.2 (DIN)
unnamed: D16.4 (DO), D17.2 (DIN)
unnamed: D17.4 (DO), D18.2 (DIN)
unnamed: D18.4 (DO), D19.2 (DIN)
unnamed: D19.4 (DO), D20.2 (DIN)
unnamed: D20.4 (DO), D21.2 (DIN)
unnamed: D21.4 (DO), D22.2 (DIN)
unnamed: D22.4 (DO), D23.2 (DIN)
unnamed: D23.4 (DO), D24.2 (DIN)
unnamed: D24.4 (DO), D25.2 (DIN)
unnamed: J3.1, U1.16 (IO7)
unnamed: J3.2, U1.22 (IO8)
unnamed: J3.3, U1.29 (IO23)
unnamed: J3.4, U1.28 (IO22)
unnamed: SW6.1 (A), U3.1 (IN)
unnamed: R7.1, U2.5 (PROG)

## Commit log

2025-09-26 First commit
    away we go!
2025-09-26 Done design
2025-09-26 Re-did almost everything
2025-09-26 Finished layout
    Finished layout and added gerbers
2025-09-27 Added CC resistors
    added USB C current declaration resistors
2025-09-27 Updated gerber
    updated gerber files to reflect changes to layout
2025-09-28 Fixed USBc
    again
